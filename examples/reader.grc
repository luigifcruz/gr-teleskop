options:
  parameters:
    author: luigi
    generate_options: qt_gui
    id: ata_guppi_reader_ex
    output_language: python
    title: ATA GUPPI Reader Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 96e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}
- name: teleskop_reader_1
  id: teleskop_reader
  parameters:
    filename: /Users/luigi/Downloads/guppi_59677_73119_16564636_AzEl_0001-beam0000.0000.raw
    hichan: '0'
    lochan: '0'
    pol: Y
    repeat: 'No'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [teleskop_reader_1, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
